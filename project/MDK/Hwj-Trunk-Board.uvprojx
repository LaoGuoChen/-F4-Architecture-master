# Keil uVision project Hwj-Trunk-Board.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Hwj-Trunk-Board +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\FreeRTOS\inc;..\..\FreeRTOS\src;..\..\Libraries\CMSIS\startup;..\..\Libraries\CMSIS;..\..\Libraries\FWlib;..\..\Libraries\FWlib\inc;..\..\Libraries\FWlib\src;..\..\source\APP;..\..\source\APP\inc;..\..\source\APP\src;..\..\source\APP_API\inc;..\..\source\APP_API\src;..\..\source\priph_cfg\inc;..\..\source\priph_cfg\src;..\..\source\system\inc;..\..\source\system\src;..\..\source\TASK\inc;..\..\source\TASK\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group PERIPH_CFG
    ../../source/priph_cfg/src/: stm32f4x_adc_config.c stm32f4x_can_config.c stm32f4x_dac_config.c stm32f4x_dma_config.c stm32f4x_exti_config.c stm32f4x_flash_config.c stm32f4x_gpio_config.c stm32f4x_i2c_config.c stm32f4x_iwdg_config.c stm32f4x_spi_config.c stm32f4x_tim_config.c stm32f4x_usart_config.c
    ../../source/priph_cfg/inc/: stm32f4x_adc_config.h stm32f4x_can_config.h stm32f4x_dac_config.h stm32f4x_dma_config.h stm32f4x_exti_config.h stm32f4x_flash_config.h stm32f4x_gpio_config.h stm32f4x_i2c_config.h stm32f4x_iwdg_config.h stm32f4x_spi_config.h stm32f4x_tim_config.h stm32f4x_usart_config.h
  group FreeRTOS
    ../../FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group APP_API
    ../../source/APP_API/src/: api_adc.c api_can.c api_exti.c api_flash.c api_i2c.c api_iwdg.c api_spi.c api_tim.c api_usart.c
    ../../source/APP_API/inc/: api_adc.h api_can.h api_exti.h api_flash.h api_i2c.h api_iwdg.h api_spi.h api_tim.h api_usart.h
  group APP
    ../../source/APP/src/: app_hal_init.c app_magnetic_encoder.c app_signal_led.c
    ../../source/APP/inc/: app_hal_init.h app_magnetic_encoder.h app_signal_led.h
  group TASK
    ../../source/TASK/src/: task_error_process.c task_signal_led.c task_uart_debug.c
    ../../source/TASK/inc/: task_error_process.h task_signal_led.h task_uart_debug.h
  group SYSTEM
    ../../source/system/src/: project_main.c
    ../../source/system/inc/: can_macro.h common.h
